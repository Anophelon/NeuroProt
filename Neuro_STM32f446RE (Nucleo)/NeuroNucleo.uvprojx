# Keil uVision project NeuroNucleo.uvprojx, settings and files
target Neuro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NeuroNucleo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\workspace\Code\src;.\workspace\Code\inc;.\workspace\FreeRTOS\inc;.\workspace\Startup
  asm include: .\workspace\Startup
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Code
    ./workspace/Code/src/: initSys.c libLCD.c libPWM.c libUART.c main.c libADC.c
  group FreeRTOS
    ./workspace/FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
